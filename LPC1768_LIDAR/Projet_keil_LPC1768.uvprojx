# Keil uVision project Projet_keil_LPC1768.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet_keil_LPC1768
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c GPIO.h LIDAR.h GPIO.c LIDAR.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:Graphic LCD 1.0.0, CMSIS Driver:SPI:SSP 2.10.0, CMSIS Driver:USART 2.13.0, Device:GPDMA 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
